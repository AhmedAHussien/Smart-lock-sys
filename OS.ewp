# IAR project OS.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C123GH6PM TexasInstruments TM4C123GH6PM
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: OS.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: alarm.c alarm.h alarm_config.h appTasks.c appTasks.h cstartup_M.c FreeRTOSConfig.h heap_2.c i2c.c i2c.h keypad.c keypad.h keypad_config.h LCD.c LCD.h lcd_config.h list.c main.c motor.c motor.h motor_config.h port.c portasm.s queue.c task.h tasks.c terminal.c terminal.h TM4C123GH6PM.h uart.c uart.h userdata.c userdata.h utils.h
